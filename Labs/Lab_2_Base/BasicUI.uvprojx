# Keil uVision project BasicUI.uvprojx, settings and files
target KL25Z Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BasicUI
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group source
    ./src/: main.c LEDs.c delay.c UART.c
  group include
    ./include/: gpio_defs.h
software components: CMSIS:CORE 5.2.0, Device:Startup 2.5.0
