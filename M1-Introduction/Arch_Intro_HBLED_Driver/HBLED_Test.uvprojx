# Keil uVision project HBLED_Test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HBLED_Test
  AfterMake: Scripts\make_call_graph.bat !L
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  link misc: --callgraph_file=mycallgraph.txt --callgraph_output=text
  group Source
    ./src/: timers.c main.c delay.c LEDs.c debug.c FX.c
software components: CMSIS:CORE 5.3.0, Device:Startup 2.5.0
