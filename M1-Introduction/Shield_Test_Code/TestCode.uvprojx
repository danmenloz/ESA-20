# Keil uVision project TestCode.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project_2_Base
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CLOCK_SETUP=1
  c misc: --diag_suppress=C0001
  c include: ./Include;./Source;./Source/LCD;./Source/Profiler
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source
    ./Source/: control.c debug.c delay.c DMA.c FX.c LEDs.c main.c sound.c threads.c timers.c UI.c
  group LCD
    ./Source/LCD/: LCD_graphics.c LCD_text.c lucida_8x13.c lucida_12x19.c lucida_20x31.c ST7789.c T6963.c touchscreen.c colors.c
  group Profiler
    ./Source/Profiler/: profile.c region.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Device:Startup 2.5.0
